options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: LNA_rf_gain
  id: variable_qtgui_range
  parameters:
    label: LNA RF Gain
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '14'
    stop: '14'
    value: '0'
  states: {}
- name: VGA_bb_gain
  id: variable_qtgui_range
  parameters:
    label: VGA BB Gain
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '2'
    stop: '62'
    value: '34'
  states: {}
- name: baseband_sampling_rate
  id: variable
  parameters:
    value: '4000000'
  states: {}
- name: dect_channel_bandwidth
  id: variable
  parameters:
    value: 1.728e6
  states: {}
- name: dect_occupied_bandwidth
  id: variable
  parameters:
    value: 1.2*dect_symbol_rate
  states: {}
- name: dect_occupied_bandwidth_0_0
  id: variable
  parameters:
    value: 1.2*dect_symbol_rate
  states: {}
- name: dect_symbol_rate
  id: variable
  parameters:
    value: '1152000'
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    label: IF Gain
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '8'
    stop: '40'
    value: '40'
  states: {}
- name: options_low_pass
  id: variable
  parameters:
    value: '1400500'
  states: {}
- name: part_id
  id: variable_qtgui_chooser
  parameters:
    label: Select Part
    labels: '["0", "1", "2", "3", "4", "5", "6", "7", "8"]'
    num_opts: '0'
    options: '[0, 1, 2, 3, 4, 5, 6, 7, 8]'
    type: int
    value: '0'
  states: {}
- name: ppm_corr
  id: variable_qtgui_range
  parameters:
    label: ppm
    orient: Qt.Horizontal
    rangeType: int
    start: '-100'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: resample_ratio
  id: variable
  parameters:
    value: int((3.0*baseband_sampling_rate/2.0)/dect_symbol_rate/4.0)
  states: {}
- name: resampler_filter_taps
  id: variable
  parameters:
    value: firdes.low_pass_2(1, 3*baseband_sampling_rate, dect_occupied_bandwidth/2, (dect_channel_bandwidth - dect_occupied_bandwidth)/2, 30)
  states: {}
- name: rx_freq
  id: variable_qtgui_chooser
  parameters:
    label: Carrier Number
    labels: '["0", "1", "2", "3", "4", "5", "6", "7", "8", "9", "10", "11", "12", "13", "14", "15", "16", "17", "18", "19", "20", "21", "22", "23", "24", "25", "26", "27", "28", "29", "30", "31", "32", "33", "34", "35", "36", "37", "38", "39", "40", "41", "42", "43", "44", "45", "46", "47", "48", "49", "50", "51", "52", "53", "54", "55", "56", "57", "58", "59", "60", "61", "62", "63"]'
    num_opts: '0'
    options: '[1897344000, 1895616000, 1893888000, 1892160000, 1890432000, 1888704000, 1886876000, 1885248000, 1883520000, 1881792000, 1899072000, 1900800000, 1902528000, 1904256000, 1905984000, 1907712000, 1909440000, 1911168000, 1912896000, 1914624000, 1916352000, 1918080000, 1919808000, 1921536000, 1923264000, 1924992000, 1926720000, 1928448000, 1930176000, 1931904000, 1933632000, 1935360000, 1937088000, 1938816000, 1940544000, 1942272000, 1944000000, 1945728000, 1947456000, 1949184000, 1950912000, 1952640000, 1954368000, 1956096000, 1957824000, 1959552000, 1961280000, 1963008000, 1964736000, 1966464000, 1968192000, 1969920000, 1971648000, 1973376000, 1975104000, 1976832000, 2011392000, 2013120000, 2014848000, 2016576000, 2018304000, 2020032000, 2021760000, 2023488000]'
    type: real
    value: '1897344000'
  states: {}
- name: xlate_offset1
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '32768'
  states: {}
- name: blocks_short_to_float_0_0
  id: blocks_short_to_float
  parameters:
    scale: '32768'
  states: {}
- name: console_0
  id: console
  parameters: {}
  states: {}
- name: console_1
  id: console
  parameters: {}
  states: {}
- name: dect2_packet_decoder_0
  id: dect2_packet_decoder
  parameters:
    part_to_decode: '0'
    rx_id: '0'
  states: {}
- name: dect2_packet_decoder_1
  id: dect2_packet_decoder
  parameters:
    part_to_decode: '1'
    rx_id: '0'
  states: {}
- name: dect2_packet_receiver_0
  id: dect2_packet_receiver
  parameters: {}
  states: {}
- name: dect2_phase_diff_0
  id: dect2_phase_diff
  parameters: {}
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: xlate_offset1
    decim: '1'
    samp_rate: baseband_sampling_rate
    taps: firdes.low_pass(1, baseband_sampling_rate, options_low_pass, options_low_pass*0.2)
    type: ccc
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: (3.0*baseband_sampling_rate/2.0)/dect_symbol_rate/4.0
    type: complex
  states: {}
- name: rational_resampler_base_xxx_0
  id: rational_resampler_base_xxx
  parameters:
    decim: '2'
    interp: '3'
    taps: resampler_filter_taps
    type: ccc
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '6'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '6'
    taps: ''
    type: fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: hackrf=0
    bb_gain0: VGA_bb_gain
    corr0: ppm_corr
    dc_offset_mode0: '2'
    freq0: rx_freq-xlate_offset1
    gain0: LNA_rf_gain
    gain_mode0: 'False'
    if_gain0: if_gain
    iq_balance_mode0: '2'
    sample_rate: baseband_sampling_rate
    sync: sync
    type: fc32
  states: {}
- name: vocoder_g721_decode_bs_0
  id: vocoder_g721_decode_bs
  parameters: {}
  states: {}
- name: vocoder_g721_decode_bs_1
  id: vocoder_g721_decode_bs
  parameters: {}
  states: {}

connections:
- [blocks_short_to_float_0, '0', rational_resampler_xxx_0, '0']
- [blocks_short_to_float_0_0, '0', rational_resampler_xxx_0_0, '0']
- [dect2_packet_decoder_0, '0', vocoder_g721_decode_bs_0, '0']
- [dect2_packet_decoder_0, log_out, console_0, in]
- [dect2_packet_decoder_1, '0', vocoder_g721_decode_bs_1, '0']
- [dect2_packet_decoder_1, log_out, console_1, in]
- [dect2_packet_receiver_0, '0', dect2_packet_decoder_0, '0']
- [dect2_packet_receiver_0, '0', dect2_packet_decoder_1, '0']
- [dect2_packet_receiver_0, rcvr_msg_out, dect2_packet_decoder_0, rcvr_msg_in]
- [dect2_packet_receiver_0, rcvr_msg_out, dect2_packet_decoder_1, rcvr_msg_in]
- [dect2_phase_diff_0, '0', dect2_packet_receiver_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', rational_resampler_base_xxx_0, '0']
- [mmse_resampler_xx_0, '0', dect2_phase_diff_0, '0']
- [rational_resampler_base_xxx_0, '0', mmse_resampler_xx_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_0_0, '0', audio_sink_0_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [vocoder_g721_decode_bs_0, '0', blocks_short_to_float_0, '0']
- [vocoder_g721_decode_bs_1, '0', blocks_short_to_float_0_0, '0']

metadata:
  file_format: 1
